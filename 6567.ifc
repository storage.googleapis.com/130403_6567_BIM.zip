Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-11T16:07:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 11 16:07:28 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{E7DD454B-47E8-4019-981C-E9EB1C2DB86A}\ifc * Database version: 5507 * Database creation date: Tue Sep 11 16:07:28 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 11 16:07:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 11 16:07:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6567 Urinal flusher, 6 V, 6567:6567 Urinal flusher, 6 V:357599
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 95 mm; NominalHeight: 261 mm; NominalWidth: 65 mm; Projection: 81 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6567; ConvergoRefNr: 0087-1809-0097-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 10/09/2018
Type - Green Building Properties(Type) - EAN Number: 6414150040351; EMC Directive: 89/336/EEC; EN Standard: EN 15091; LVI Number: 6413151; NRF Number: 4202799; Protection Class: IP 55; RSK Number: 7981013; STF Certificate: STF VTT-RTH-00104-11; VVS Number: 618852134
Type - Identity Data(Type) - Class: Battery-operated, touchless; Group: Urinals; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6567 Urinal flusher, 6 V; Name_en: 6567 Urinal flusher, 6 V; OmniClass Number: 23.45.05.14.99; OmniClass Title: Other Sanitary Washing Plumbing Fixtures; Product Code: 6567; Product Datasheet: https://www.oras.com/datasheet/6567/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6567; Type Name: 6567 Urinal flusher, 6 V; Usage Group: Offices, personnel sanitary facilities;Health centers & Child welfare clinics;Hospitals;Gas stations;Schools
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Afterflush Period: 6 s (3 / 6 / 10 s); Automatic Flush: 24 h ON (ON / OFF); Flow Rate At 300kPa: 0.0197762 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/72554_PDM_945547_7_(945547-12-16).pdf; Installation Type: Wall-mounted; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: Litter filter(s);Shut-off valve; Pre-flush Period: 2 s ON (ON / OFF); Pressure Loss With Flow 02ls: 40000 Pa; Recognition Range: 40 cm (30 / 40 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6567/
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6567; Features: Battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6567; Name: 6567 Urinal flusher, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: 65x95x260 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6567; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6567 Urinal flusher, 6 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0495058 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; OutletAngle: 0 deg; Volume: 0.00162424 m3
Identity Data - Mark: 20
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6567: 6567 Urinal flusher, 6 V; Family and Type: 6567: 6567 Urinal flusher, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6567: 6567 Urinal flusher, 6 V; Type Id: 6567: 6567 Urinal flusher, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
